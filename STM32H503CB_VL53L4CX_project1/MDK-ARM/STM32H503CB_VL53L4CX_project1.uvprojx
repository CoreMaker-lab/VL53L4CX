# Keil uVision project STM32H503CB_VL53L4CX_project1.uvprojx, settings and files
target STM32H503CB_VL53L4CX_project1 (6140001::V6.14.1::ARMCLANG)
  device: STM32H503CBTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x801FFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: STM32H503CB_VL53L4CX_project1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H503xx
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../TOF/App;../TOF/Target;../Drivers/BSP/custom;../Drivers/BSP/Components/vl53l4cx/modules;../Drivers/BSP/Components/vl53l4cx/porting;../Drivers/BSP/Components/vl53l4cx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c bsp.c icache.c memorymap.c custom_bus.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Application/User/TOF/Target
    ../TOF/Target/: custom_ranging_sensor.c
  group Application/User/TOF/App
    ../TOF/App/: app_tof.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/vl53l4cx/modules/: vl53lx_api.c vl53lx_api_calibration.c vl53lx_api_core.c vl53lx_api_debug.c vl53lx_api_preset_modes.c vl53lx_core.c vl53lx_core_support.c vl53lx_dmax.c vl53lx_hist_algos_gen3.c vl53lx_hist_algos_gen4.c vl53lx_hist_char.c vl53lx_hist_core.c vl53lx_hist_funcs.c vl53lx_nvm.c vl53lx_nvm_debug.c vl53lx_register_funcs.c vl53lx_sigma_estimate.c vl53lx_silicon_core.c vl53lx_wait.c vl53lx_xtalk.c
    ../Drivers/BSP/Components/vl53l4cx/porting/: vl53lx_platform.c vl53lx_platform_ipp.c vl53lx_platform_log.c
    ../Drivers/BSP/Components/vl53l4cx/: vl53l4cx.c
  group Drivers/BSP/custom
    ../Drivers/BSP/custom/: custom.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../Drivers/BSP/Components/Components/vl53l4cx/modules/: LXReleaseNotes.txt
    ../Drivers/BSP/Components/Components/vl53l4cx/: LICENSE.txt
software components: CMSIS:CORE 4.3.0
